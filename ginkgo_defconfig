## ginkgo_defconfig
```kconfig
# CONFIG_KSU=y
# CONFIG_SUSFS=y
# CONFIG_SUSFS_HOOK_MODE_MANUAL=y
# CONFIG_ZRAM=y
# CONFIG_SCHED_MAPLE=y
```
